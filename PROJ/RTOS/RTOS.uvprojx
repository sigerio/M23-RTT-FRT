# Keil uVision project RTOS.uvprojx, settings and files
target RTOS (6220000::V6.22::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32L233
  c include: ..\..\Bsp;..\..\Usr;..\..\Utilities;..\..\mem_task;..\..\RTOS_CFG;..\..\RTOS_CFG\M23;..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32L23x\Include;..\..\RTOS_CFG\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group start
    ../../Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
    ../../Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l233xx.s
  group Firm
    ../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_can.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
  group Usr
    ../../Usr/: main.c
  group Mem
    ../../mem_task/: hook.c mem_task.c
  group Bsp
    ../../Bsp/: bord.c gpio.c
  group Intrupu
    ../../Utilities/: gd32l23x_it.c
  group Cfg
    ../../RTOS_CFG/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
    ../../RTOS_CFG/M23/: port.c portasm.c
